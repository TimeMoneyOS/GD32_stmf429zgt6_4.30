<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GD32_stmf429zgt6_4.30.ewp</path>
  </project>
  <batchBuild />
</workspace>
